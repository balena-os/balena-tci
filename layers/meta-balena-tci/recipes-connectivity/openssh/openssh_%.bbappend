FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Add-clock_nanosleep_time64-to_sandbox-seccomp-filter.patch"
